options:
  parameters:
    author: Andres Cañizares  Karen Prada
    generate_options: qt_gui
    id: ModuladordeAmplitud
    output_language: python
    title: Modulador de Amplitud
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud de portadora (Ac)
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0.125'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje (Am)
    start: '0'
    step: '0.1'
    stop: '4'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: ganancia del trasnmisor (GTX)
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: Ka
  id: variable_qtgui_range
  parameters:
    label: Ka
    start: '0'
    step: '0.1'
    stop: '4'
    value: '1'
  states: {}
- name: OFFSET
  id: variable_qtgui_range
  parameters:
    label: OFFSET
    start: '-1/Ka'
    step: '1'
    stop: 1/Ka
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia portadora (fc)
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia mensaje (fm)
    start: '300'
    step: '100'
    stop: '21000'
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12500000/64
  states: {}
- name: EnvolventeComplejaDSB_0
  id: EnvolventeComplejaDSB
  parameters:
    Ac: Ac
    Ka: Ka
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: OFFSET
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: potencia_0
  id: potencia
  parameters:
    l_vect: '1024'
  states: {}
- name: potencia_1
  id: potencia
  parameters:
    l_vect: '1024'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    clock_source0: internal
    gain0: GTX
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [EnvolventeComplejaDSB_0, '0', blocks_complex_to_real_0, '0']
- [EnvolventeComplejaDSB_0, '0', blocks_throttle_0, '0']
- [EnvolventeComplejaDSB_0, '0', qtgui_freq_sink_x_0, '0']
- [EnvolventeComplejaDSB_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', EnvolventeComplejaDSB_0, '0']
- [analog_sig_source_x_0, '0', potencia_1, '0']
- [blocks_complex_to_real_0, '0', potencia_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
